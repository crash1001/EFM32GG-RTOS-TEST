# Keil uVision project RTOS-TEST.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: EFM32GG980F1024 Energy Micro
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0xFFFFF) CLOCK(48000000) CPUTYPE("Cortex-M3")
  output: RTOS-TEST
  c flags: Optim=1
  c include: ..\..\lib\emlib\inc;..\..\lib\config;..\..\lib\RTOS\include;..\..\lib\RTOS\ARM_CM3;..\..\lib\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: startup_efm32gg.s
    ../../lib/config/: system_efm32gg.c
  group src
    ../src/: main.c
  group emlib
    ../../lib/emlib/src/: em_gpio.c em_cmu.c em_assert.c em_core.c em_emu.c em_system.c em_rtc.c em_rmu.c
  group rtos
    ../../lib/RTOS/: list.c tasks.c
    ../../lib/RTOS/memory-manage/: heap_4.c
    ../../lib/RTOS/ARM_CM3/: port.c
